# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=2
  c define: USE_HAL_DRIVER, STM32L475xx
  c include: .;..\..\rt-thread-4.0.1\include;.;applications;board;board\CubeMX_Config\Inc;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;..\..\libraries\HAL_Drivers\drv_flash;packages\aht10-latest;packages\EasyFlash-latest\inc;ports\EasyFlash;packages\fal-latest\inc;ports\fal;..\..\rt-thread-4.0.1\libcpu\arm\common;..\..\rt-thread-4.0.1\libcpu\arm\cortex-m4;..\..\rt-thread-4.0.1\components\dfs\include;..\..\rt-thread-4.0.1\components\dfs\filesystems\devfs;..\..\rt-thread-4.0.1\components\dfs\filesystems\elmfat;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\spi;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\spi\sfud\inc;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\sensors;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\finsh;..\..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\..\libraries\STM32L4xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep *.o(.rti_fn.*) --keep *.o(FSymTab)
  group Kernel
    ../../rt-thread-4.0.1/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: dfs_sample.c fal_sample.c main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    ../../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    ../../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_qspi.c drv_soft_i2c.c drv_common.c
    ../../libraries/HAL_Drivers/drv_flash/: drv_flash_l4.c
  group aht10
    packages/aht10-latest/: aht10.c sensor_asair_aht10.c
  group EasyFlash
    packages/EasyFlash-latest/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/EasyFlash/: ef_fal_port.c
  group fal
    packages/fal-latest/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_sfud_port.c
  group cpu
    ../../rt-thread-4.0.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread-4.0.1/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../rt-thread-4.0.1/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../rt-thread-4.0.1/components/dfs/filesystems/devfs/: devfs.c
    ../../rt-thread-4.0.1/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../rt-thread-4.0.1/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../rt-thread-4.0.1/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../rt-thread-4.0.1/components/drivers/misc/: pin.c
    ../../rt-thread-4.0.1/components/drivers/serial/: serial.c
    ../../rt-thread-4.0.1/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../rt-thread-4.0.1/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread-4.0.1/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Sensors
    ../../rt-thread-4.0.1/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    ../../rt-thread-4.0.1/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group STM32_HAL
    ../../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c
