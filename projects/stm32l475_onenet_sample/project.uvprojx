# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=4 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32L475xx
  c include: .;..\..\rt-thread-4.0.1\include;.;applications;board;board\CubeMX_Config\Inc;..\..\libraries\HAL_Drivers;..\..\libraries\HAL_Drivers\config;..\..\libraries\HAL_Drivers\drv_flash;packages\aht10-v2.0.0;packages\cJSON-v1.0.2;packages\EasyFlash-v3.3.0\inc;ports\EasyFlash;packages\fal-v0.3.0\inc;ports\fal;packages\onenet-latest\inc;packages\ota_downloader-v1.0.0;packages\pahomqtt-v1.1.0\MQTTPacket\src;packages\pahomqtt-v1.1.0\MQTTClient-RT;packages\webclient-v2.1.2\inc;ports\wifi;..\..\libraries\wifi;..\..\rt-thread-4.0.1\libcpu\arm\common;..\..\rt-thread-4.0.1\libcpu\arm\cortex-m4;..\..\rt-thread-4.0.1\components\dfs\include;..\..\rt-thread-4.0.1\components\dfs\filesystems\devfs;..\..\rt-thread-4.0.1\components\dfs\filesystems\elmfat;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\spi;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\spi\sfud\inc;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\drivers\wlan;..\..\rt-thread-4.0.1\components\drivers\sensors;..\..\rt-thread-4.0.1\components\drivers\include;..\..\rt-thread-4.0.1\components\finsh;..\..\rt-thread-4.0.1\components\libc\compilers\armlibc;..\..\rt-thread-4.0.1\components\libc\compilers\common;..\..\rt-thread-4.0.1\components\net\lwip-2.0.2\src;..\..\rt-thread-4.0.1\components\net\lwip-2.0.2\src\include;..\..\rt-thread-4.0.1\components\net\lwip-2.0.2\src\include\ipv4;..\..\rt-thread-4.0.1\components\net\lwip-2.0.2\src\arch\include;..\..\rt-thread-4.0.1\components\net\lwip-2.0.2\src\include\netif;..\..\rt-thread-4.0.1\components\net\netdev\include;..\..\rt-thread-4.0.1\components\net\sal_socket\include;..\..\rt-thread-4.0.1\components\net\sal_socket\include\socket;..\..\rt-thread-4.0.1\components\net\sal_socket\impl;..\..\rt-thread-4.0.1\components\net\sal_socket\include\dfs_net;..\..\rt-thread-4.0.1\components\net\sal_socket\include\dfs_net\sys_select;..\..\rt-thread-4.0.1\components\net\sal_socket\include\socket\sys_socket;..\..\rt-thread-4.0.1\components\utilities\ymodem;..\..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\..\libraries\STM32L4xx_HAL\CMSIS\Include;..\..\libraries\rt_ota\inc
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep *.o(.rti_fn.*) --keep *.o(FSymTab)
  group Kernel
    ../../rt-thread-4.0.1/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: drv_qspi_flash.c main.c sensor_port.c sockapi_http_demo.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    ../../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l475xx.s
    ../../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_spi.c drv_qspi.c drv_soft_i2c.c drv_sdio.c drv_wlan.c drv_common.c
    ../../libraries/HAL_Drivers/drv_flash/: drv_flash_l4.c
  group aht10
    packages/aht10-v2.0.0/: aht10.c sensor_asair_aht10.c
  group cJSON
    packages/cJSON-v1.0.2/: cJSON.c cJSON_port.c cJSON_util.c
  group EasyFlash
    packages/EasyFlash-v3.3.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ports/EasyFlash/: ef_fal_port.c
  group fal
    packages/fal-v0.3.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
    ports/fal/: fal_flash_sfud_port.c
  group onenet
    packages/onenet-latest/src/: onenet_http.c onenet_mqtt.c
  group ota_downloader
    packages/ota_downloader-v1.0.0/src/: http_ota.c
  group paho-mqtt
    packages/pahomqtt-v1.1.0/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-v1.1.0/MQTTClient-RT/: paho_mqtt_pipe.c
    packages/pahomqtt-v1.1.0/samples/: mqtt_sample.c
  group WebClient
    packages/webclient-v2.1.2/src/: webclient.c webclient_file.c
  group wifi
    ports/wifi/: wifi_config.c
  group wifi
    ../../libraries/wifi/: libwifi_6181_0.2.5_armcm4_keil.lib
  group cpu
    ../../rt-thread-4.0.1/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../rt-thread-4.0.1/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../rt-thread-4.0.1/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../rt-thread-4.0.1/components/dfs/filesystems/devfs/: devfs.c
    ../../rt-thread-4.0.1/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../rt-thread-4.0.1/components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../rt-thread-4.0.1/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../rt-thread-4.0.1/components/drivers/misc/: pin.c
    ../../rt-thread-4.0.1/components/drivers/rtc/: rtc.c soft_rtc.c
    ../../rt-thread-4.0.1/components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../rt-thread-4.0.1/components/drivers/serial/: serial.c
    ../../rt-thread-4.0.1/components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../rt-thread-4.0.1/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../rt-thread-4.0.1/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../rt-thread-4.0.1/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Sensors
    ../../rt-thread-4.0.1/components/drivers/sensors/: sensor.c sensor_cmd.c
  group finsh
    ../../rt-thread-4.0.1/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../rt-thread-4.0.1/components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../rt-thread-4.0.1/components/libc/compilers/common/: gmtime_r.c
  group lwIP
    ../../rt-thread-4.0.1/components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../rt-thread-4.0.1/components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../rt-thread-4.0.1/components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../rt-thread-4.0.1/components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../rt-thread-4.0.1/components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../rt-thread-4.0.1/components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    ../../rt-thread-4.0.1/components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../rt-thread-4.0.1/components/net/sal_socket/src/: sal_socket.c
    ../../rt-thread-4.0.1/components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../rt-thread-4.0.1/components/net/sal_socket/impl/: af_inet_lwip.c
    ../../rt-thread-4.0.1/components/net/sal_socket/dfs_net/: dfs_net.c
  group Utilities
    ../../rt-thread-4.0.1/components/utilities/ymodem/: ymodem.c
  group STM32_HAL
    ../../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
    ../../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_gpio.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c
  group rt_ota
    ../../libraries/rt_ota/libs/: librt_ota_noalgo_0.1.2_stm32l4_keil.lib
